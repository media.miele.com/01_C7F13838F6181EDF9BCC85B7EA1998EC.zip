Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 7d9c16e9-3bc1-411e-9eff-b20a2a65fa4c, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-05T10:59:02+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12082210_CH_DGC7640-55_GRGR:23764031_CH_12082210_DGC7640-55_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_GRGR, <Unnamed>, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 547 mm; Height: 507 mm; Depth: 573 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 23764031_CH_12082210_DGC7640-55_GRGR; sets with these values: 2

# IfcDistributionPort, Port_354823_1
Description: Flow; FlowDirection: SOURCEANDSINK
